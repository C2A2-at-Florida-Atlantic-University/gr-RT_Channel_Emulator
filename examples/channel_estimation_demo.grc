options:
  parameters:
    comment: Shared GLFSR vector -> RT -> standard GNU Radio blocks for periodic L-tap LS, primary RT tap-energy SNR, and secondary repeated-probe SNR.
    description: Standard-block GLFSR correlation and exact LS correction; only RT is custom. Amplitude controls are outside the RT block.
    generate_options: qt_gui
    id: channel_estimation_demo
    output_language: python
    title: GLFSR / LS Channel Estimation - FAU
  states: {}

blocks:
- name: comparison_hz
  id: variable
  parameters:
    comment: LS estimates per second; each solve uses consecutive IQ samples.
    value: '5.0'
  states: {}
- name: correlation_weights
  id: variable
  parameters:
    comment: conj(FFT(probe))/(N*M); validates the GLFSR autocorrelation needed by LS.
    value: glfsr_correlation_spectrum(glfsr, num_taps, periods_per_estimate)
  states: {}
- name: glfsr
  id: variable
  parameters:
    comment: Shared 255-sample bipolar probe; used unchanged by Vector Source and LS.
    value: (1,-1,1,1,-1,-1,-1,1,1,1,1,-1,1,-1,-1,-1,-1,1,1,1,1,1,1,1,1,-1,-1,1,-1,-1,-1,-1,1,-1,1,-1,-1,1,1,1,1,1,-1,1,-1,1,-1,1,-1,1,1,1,-1,-1,-1,-1,-1,1,1,-1,-1,-1,1,-1,1,-1,1,1,-1,-1,1,1,-1,-1,1,-1,1,1,1,1,1,1,-1,1,1,1,1,-1,-1,1,1,-1,1,1,1,-1,1,1,1,-1,-1,1,-1,1,-1,1,-1,-1,1,-1,1,-1,-1,-1,1,-1,-1,1,-1,1,1,-1,1,-1,-1,-1,1,1,-1,-1,1,1,1,-1,-1,1,1,1,1,-1,-1,-1,1,1,-1,1,1,-1,-1,-1,-1,1,-1,-1,-1,1,-1,1,1,1,-1,1,-1,1,1,1,1,-1,1,1,-1,1,1,1,1,1,-1,-1,-1,-1,1,1,-1,1,-1,-1,1,1,-1,1,-1,1,1,-1,1,1,-1,1,-1,1,-1,-1,-1,-1,-1,1,-1,-1,1,1,1,-1,1,1,-1,-1,1,-1,-1,1,-1,-1,1,1,-1,-1,-1,-1,-1,-1,1,1,1,-1,1,-1,-1,1,-1,-1,-1,1,1,1,-1,-1,-1,1,-1,-1,-1,-1,-1,-1,-1)
  states: {}
- name: l_max
  id: variable
  parameters:
    value: '16'
  states: {}
- name: l_min
  id: variable
  parameters:
    value: '0'
  states: {}
- name: noise_voltage
  id: variable_qtgui_range
  parameters:
    comment: Linear complex RMS amplitude sigma; noise power = sigma**2; zero disables noise.
    gui_hint: 2,0,1,3
    label: Noise Voltage (linear RMS)
    min_len: '300'
    start: '0'
    step: '0.001'
    stop: '1'
    value: '0.001'
  states: {}
- name: num_taps
  id: variable
  parameters:
    comment: Shared RT and LS vector length, including zero taps. Change the lag range and regenerate.
    value: l_max - l_min + 1
  states: {}
- name: periods_per_estimate
  id: variable
  parameters:
    comment: 'M: consecutive periods averaged per LS estimate.'
    value: '8'
  states: {}
- name: probe_len
  id: variable
  parameters:
    comment: 'N: samples in one known probe period.'
    value: len(glfsr)
  states: {}
- name: rx_amplitude
  id: variable_qtgui_range
  parameters:
    comment: External RX multiplier scales both received signal and noise.
    gui_hint: 1,0,1,3
    label: RX Amplitude (linear)
    min_len: '300'
    start: '0'
    step: '1'
    stop: '100'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: Complex samples per second; not the GUI refresh rate.
    value: '1000000'
  states: {}
- name: sample_offset
  id: variable
  parameters:
    comment: Known GNU Radio 3.10.12 RT startup advance; compensate using Delay.
    value: max(2, num_taps) + 1
  states: {}
- name: tx_amplitude
  id: variable_qtgui_range
  parameters:
    comment: External TX multiplier before propagation and noise.
    gui_hint: 0,0,1,3
    label: TX Amplitude (linear)
    min_len: '300'
    start: '0'
    step: '1'
    stop: '100'
    value: '1'
  states: {}
- name: window_decimation
  id: variable
  parameters:
    comment: Keep whole observation windows; do not decimate samples within a period.
    value: max(1, round(samp_rate / (window_size * comparison_hz)))
  states: {}
- name: window_size
  id: variable
  parameters:
    comment: Consecutive samples per LS estimate (8 complete periods = 2040 samples).
    value: periods_per_estimate * probe_len
  states: {}
- name: add_correction
  id: blocks_add_xx
  parameters:
    comment: 12. r[j] + c; removes the GLFSR correlation sidelobe bias.
    type: complex
  states: {}
- name: align_rx
  id: blocks_delay
  parameters:
    comment: 2. Restore probe phase by delaying RX by the known startup advance.
    delay: sample_offset
    type: complex
  states: {}
- name: correlate
  id: blocks_multiply_const_vxx
  parameters:
    comment: 8. Multiply by conj(FFT(known probe))/(N*M).
    const: correlation_weights
    type: complex
    vlen: probe_len
  states: {}
- name: correlation_stream
  id: blocks_vector_to_stream
  parameters:
    num_items: probe_len
    type: complex
  states: {}
- name: fft_received
  id: fft_vxx
  parameters:
    comment: 7. FFT of received period sum; no window or frequency shift.
    fft_size: probe_len
    forward: 'True'
    shift: 'False'
    type: complex
    window: '[]'
  states: {}
- name: ifft_correlation
  id: fft_vxx
  parameters:
    comment: 9. Inverse FFT yields average correlation r = X^H y.
    fft_size: probe_len
    forward: 'False'
    shift: 'False'
    type: complex
    window: '[]'
  states: {}
- name: import_ls_setup
  id: import
  parameters:
    imports: from rt_channel_emulation.estimation import glfsr_correlation_spectrum
  states: {}
- name: keep_lags
  id: blocks_keep_m_in_n
  parameters:
    comment: 10. Keep the L correlations for the modeled FIR indices 0..L-1.
    m: num_taps
    n: probe_len
    offset: '0'
    type: complex
  states: {}
- name: ls_magnitude
  id: blocks_complex_to_mag
  parameters:
    vlen: num_taps
  states: {}
- name: ls_tap_stream
  id: blocks_vector_to_stream
  parameters:
    comment: Unpack one LS magnitude vector in tap order for one stem-plot frame.
    num_items: num_taps
    type: float
  states: {}
- name: ls_taps
  id: blocks_stream_to_vector
  parameters:
    comment: 14. One vector of L complex LS taps.
    num_items: num_taps
    type: complex
  states: {}
- name: model_snr_db
  id: blocks_nlog10_ff
  parameters:
    comment: Primary SNR 5. 10*log10(P_signal/P_noise), in dB; tap-energy prediction, not a received-sample measurement. Power floors limit zero-input readings.
    k: '0'
    n: '10'
  states: {}
- name: model_snr_ratio
  id: blocks_multiply_const_xx
  parameters:
    comment: Primary SNR 4. Divide by known received noise power (RX*sigma)^2. RX scales signal and noise equally, so it cancels above the numerical floor.
    const: 1.0 / max((rx_amplitude * noise_voltage)**2, 1e-20)
    type: float
  states: {}
- name: model_snr_signal_floor
  id: blocks_max_xx
  parameters:
    comment: Primary SNR 3. Guard log(0) with the existing 1e-20 power floor. No signal, zero noise, or RX=0 gives a numerical placeholder, not physical SNR.
    num_inputs: '2'
    type: float
  states: {}
- name: model_snr_signal_scale
  id: blocks_multiply_const_xx
  parameters:
    comment: Primary SNR 2b. Predicted received signal power = (TX*RX)^2*sum(|h|^2). Both controls are linear amplitudes, so square their product for power.
    const: (tx_amplitude * rx_amplitude)**2
    type: float
  states: {}
- name: model_snr_tap_energy
  id: blocks_integrate_xx
  parameters:
    comment: Primary SNR 2a. Sum L squared tap magnitudes = sum(|h|^2). Zero-mean, unit-power uncorrelated-input assumption; finite GLFSR is approximate.
    decim: num_taps
    type: float
  states: {}
- name: model_snr_tap_power
  id: blocks_complex_to_mag_squared
  parameters:
    comment: Primary SNR 1a. Squared magnitude of each complex RT tap, |h[k]|^2. Calculate power directly, without a magnitude/square-root approximation.
    vlen: num_taps
  states: {}
- name: model_snr_tap_stream
  id: blocks_vector_to_stream
  parameters:
    comment: Primary SNR 1b. Unpack each L-element tap-power vector for Integrate.
    num_items: num_taps
    type: float
  states: {}
- name: normalize_ls
  id: blocks_multiply_const_xx
  parameters:
    comment: '13. Exact L-tap LS: h[j] = (r[j] + c)/(N+1).'
    const: 1.0 / (probe_len + 1)
    type: complex
  states: {}
- name: period_vectors
  id: blocks_stream_to_vector
  parameters:
    comment: 4. One vector contains one complete probe period.
    num_items: probe_len
    type: complex
  states: {}
- name: probe_source
  id: blocks_vector_source_x
  parameters:
    comment: 1. Repeating known probe; imaginary part is zero.
    repeat: 'True'
    type: complex
    vector: glfsr
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    comment: Primary RT tap-energy prediction and secondary repeated-probe estimate. Both emit at the decimated estimate rate; updates are not sample-synchronized.
    grid: 'True'
    gui_hint: 5,0,1,3
    label1: SNR (model)
    label2: SNR (measured)
    name: SNR comparison
    nconnections: '2'
    size: '5'
    srate: samp_rate / (window_size * window_decimation)
    type: float
    update_time: '0.1'
    ylabel: SNR
    yunit: dB
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    comment: Received samples after the external RX amplitude multiplier.
    gui_hint: 4,0,1,3
    label1: I
    label2: Q
    name: '"RX Signal"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: repeat_correction
  id: blocks_repeat
  parameters:
    comment: 11c. Repeat c once for each of the L correlations.
    interp: num_taps
    type: complex
  states: {}
- name: rt_channel
  id: rt_channel_emulation_rt_channel_emulation
  parameters:
    carrier_frequency_hz: 2.4e9
    epsilon: '1.0'
    frequency_offset: '0.0'
    l_max: l_max
    l_min: l_min
    max_depth: '5'
    noise_voltage: noise_voltage
    rx_pattern: iso
    rx_polarization: V
    rx_position: '[28.0, 25.0, 1.0]'
    sample_rate: samp_rate
    scene_path: /Users/josea/Workspaces/gr-RT_channel_emulation/python/rt_channel_emulation/scenes/FAU_scene/FAU_scene.xml
    seed: '42'
    tap_decimation: window_size * window_decimation
    tap_output: 'True'
    tx_pattern: iso
    tx_polarization: V
    tx_position: '[28.0, 26.0, 1.0]'
    visualize: 'True'
  states: {}
- name: rt_magnitude
  id: blocks_complex_to_mag
  parameters:
    vlen: num_taps
  states: {}
- name: rt_tap_stream
  id: blocks_vector_to_stream
  parameters:
    comment: Unpack one RT magnitude vector in tap order for one stem-plot frame.
    num_items: num_taps
    type: float
  states: {}
- name: rx_position_socket
  id: network_socket_pdu
  parameters:
    comment: One UDP datagram = RX [X, Y, Z] JSON array; updates are independent of TX.
    host: 127.0.0.1
    mtu: '1024'
    port: '52002'
    type: UDP_SERVER
  states: {}
- name: rx_scale
  id: blocks_multiply_const_xx
  parameters:
    comment: External RX amplitude scales signal AND channel noise; it does not improve SNR.
    const: rx_amplitude
    type: complex
  states: {}
- name: scale_correction
  id: blocks_multiply_const_xx
  parameters:
    comment: 11b. LS correction c = sum(r)/(N+1-L).
    const: 1.0 / (probe_len + 1 - num_taps)
    type: complex
  states: {}
- name: select_windows
  id: blocks_keep_one_in_n
  parameters:
    comment: 6. Limit processing to approximately comparison_hz estimates/s.
    n: window_decimation
    type: complex
    vlen: probe_len
  states: {}
- name: skip_startup
  id: blocks_skiphead
  parameters:
    comment: 3. Discard complete startup periods; retain phase-zero framing.
    num_items: probe_len * (1 + sample_offset // probe_len)
    type: complex
  states: {}
- name: snr_db
  id: blocks_nlog10_ff
  parameters:
    comment: Secondary SNR 8. 10*log10(P_signal/P_noise) measured from repeated RX samples, in dB. Not Eb/N0 and not LS processing gain.
    k: '0'
    n: '10'
  states: {}
- name: snr_difference
  id: blocks_sub_xx
  parameters:
    comment: SNR 2. d[n]=y[n]-y[n-N]. Repeated signal cancels; independent noise variances add.
    type: complex
  states: {}
- name: snr_difference_power
  id: blocks_complex_to_mag_squared
  parameters:
    comment: SNR 3. Squared complex magnitude |d[n]|^2, not magnitude.
  states: {}
- name: snr_noise_floor
  id: blocks_max_xx
  parameters:
    comment: Numerical guard only, not injected noise. Zero-noise readings are floor-limited, not finite physical SNR.
    num_inputs: '2'
    type: float
  states: {}
- name: snr_noise_mean
  id: blocks_multiply_const_xx
  parameters:
    comment: SNR 5. P_noise = mean(|y[n]-y[n-N]|^2)/2. Estimates noise before LS averaging.
    const: 0.5 / window_size
    type: float
  states: {}
- name: snr_noise_sum
  id: blocks_integrate_xx
  parameters:
    comment: SNR 4. Sum one window of M*N consecutive difference powers.
    decim: window_size
    type: float
  states: {}
- name: snr_period_delay
  id: blocks_delay
  parameters:
    comment: SNR 1. Delay RX by N=len(glfsr). A static channel preserves the known probe period.
    delay: probe_len
    type: complex
  states: {}
- name: snr_power_floor
  id: analog_const_source_x
  parameters:
    comment: Numerical floor for Max blocks; this constant is not added to the IQ signal.
    const: '1e-20'
    type: float
  states: {}
- name: snr_ratio
  id: blocks_divide_xx
  parameters:
    comment: SNR 7. Signal-power estimate divided by noise-power estimate.
    type: float
  states: {}
- name: snr_received_power
  id: blocks_complex_to_mag_squared
  parameters:
    comment: SNR 3. Total received power samples |y[n]|^2.
  states: {}
- name: snr_select_noise
  id: blocks_keep_one_in_n
  parameters:
    comment: Keep whole power estimates at the same rate on both branches.
    n: window_decimation
    type: float
  states: {}
- name: snr_select_total
  id: blocks_keep_one_in_n
  parameters:
    comment: Identical window selection to the noise branch.
    n: window_decimation
    type: float
  states: {}
- name: snr_signal_floor
  id: blocks_max_xx
  parameters:
    comment: Numerical guard for nonpositive signal estimates. Near no signal the SNR reading is unreliable.
    num_inputs: '2'
    type: float
  states: {}
- name: snr_signal_power
  id: blocks_sub_xx
  parameters:
    comment: SNR 6. P_signal = P_total - P_noise; finite-window estimates may be negative near no signal.
    type: float
  states: {}
- name: snr_skip_noise
  id: blocks_skiphead
  parameters:
    comment: Discard channel and one-period delay startup; same sample indices as the total-power branch.
    num_items: probe_len * (2 + sample_offset // probe_len)
    type: complex
  states: {}
- name: snr_skip_signal
  id: blocks_skiphead
  parameters:
    comment: Match the noise branch startup discard; retain consecutive samples, not averaged periods.
    num_items: probe_len * (2 + sample_offset // probe_len)
    type: complex
  states: {}
- name: snr_total_mean
  id: blocks_multiply_const_xx
  parameters:
    comment: SNR 5. P_total = mean(|y[n]|^2), including signal and noise.
    const: 1.0 / window_size
    type: float
  states: {}
- name: snr_total_sum
  id: blocks_integrate_xx
  parameters:
    comment: SNR 4. Sum the corresponding M*N received-signal powers.
    decim: window_size
    type: float
  states: {}
- name: sum_lags
  id: blocks_integrate_xx
  parameters:
    comment: 11a. Sum the L correlations belonging to this estimate.
    decim: num_taps
    type: complex
  states: {}
- name: sum_periods
  id: blocks_integrate_xx
  parameters:
    comment: 5. Sum M consecutive periods; correlation_weights includes division by M.
    decim: periods_per_estimate
    type: complex
    vlen: probe_len
  states: {}
- name: tap_plot
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color1: dark blue
    comment: One L-tap vector per frame; time means FIR delay j/samp_rate, not elapsed run time. Sionna lag = l_min+j. Fixed Y min keeps the stem baseline at zero; increase Y max for larger taps.
    entags: 'False'
    grid: 'True'
    gui_hint: 3,0,1,3
    label1: LS estimate
    label2: RT propagation reference
    legend: 'False'
    marker1: '0'
    marker2: '0'
    name: LS vs RT tap magnitudes (time = FIR delay)
    nconnections: '2'
    size: num_taps
    srate: samp_rate
    stemplot: 'True'
    type: float
    update_time: '0.1'
    width1: '2'
    ylabel: Tap magnitude
    ymin: '0.0'
  states: {}
- name: throttle
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: tx_position_socket
  id: network_socket_pdu
  parameters:
    comment: One UDP datagram = TX [X, Y, Z] JSON array in scene-local metres.
    host: 127.0.0.1
    mtu: '1024'
    port: '52001'
    type: UDP_SERVER
  states: {}
- name: tx_scale
  id: blocks_multiply_const_xx
  parameters:
    comment: External experimenter-controlled TX amplitude; RT taps are unchanged.
    const: tx_amplitude
    type: complex
  states: {}
- name: tx_scale_0_0
  id: blocks_multiply_const_xx
  parameters:
    comment: Scale RT magnitudes by known TX*RX amplitudes for the tap plot. The RT block's propagation taps remain unchanged.
    const: tx_amplitude * rx_amplitude
    type: float
  states: {}

connections:
- [add_correction, '0', normalize_ls, '0']
- [align_rx, '0', skip_startup, '0']
- [correlate, '0', ifft_correlation, '0']
- [correlation_stream, '0', keep_lags, '0']
- [fft_received, '0', correlate, '0']
- [ifft_correlation, '0', correlation_stream, '0']
- [keep_lags, '0', add_correction, '0']
- [keep_lags, '0', sum_lags, '0']
- [ls_magnitude, '0', ls_tap_stream, '0']
- [ls_tap_stream, '0', tap_plot, '0']
- [ls_taps, '0', ls_magnitude, '0']
- [model_snr_db, '0', qtgui_time_sink_x_0, '0']
- [model_snr_ratio, '0', model_snr_db, '0']
- [model_snr_signal_floor, '0', model_snr_ratio, '0']
- [model_snr_signal_scale, '0', model_snr_signal_floor, '0']
- [model_snr_tap_energy, '0', model_snr_signal_scale, '0']
- [model_snr_tap_power, '0', model_snr_tap_stream, '0']
- [model_snr_tap_stream, '0', model_snr_tap_energy, '0']
- [normalize_ls, '0', ls_taps, '0']
- [period_vectors, '0', sum_periods, '0']
- [probe_source, '0', throttle, '0']
- [repeat_correction, '0', add_correction, '1']
- [rt_channel, '0', rx_scale, '0']
- [rt_channel, '1', model_snr_tap_power, '0']
- [rt_channel, '1', rt_magnitude, '0']
- [rt_magnitude, '0', rt_tap_stream, '0']
- [rt_tap_stream, '0', tx_scale_0_0, '0']
- [rx_position_socket, pdus, rt_channel, rx_position]
- [rx_scale, '0', align_rx, '0']
- [rx_scale, '0', qtgui_time_sink_x_0_0, '0']
- [rx_scale, '0', snr_difference, '0']
- [rx_scale, '0', snr_period_delay, '0']
- [rx_scale, '0', snr_skip_signal, '0']
- [scale_correction, '0', repeat_correction, '0']
- [select_windows, '0', fft_received, '0']
- [skip_startup, '0', period_vectors, '0']
- [snr_db, '0', qtgui_time_sink_x_0, '1']
- [snr_difference, '0', snr_skip_noise, '0']
- [snr_difference_power, '0', snr_noise_sum, '0']
- [snr_noise_floor, '0', snr_ratio, '1']
- [snr_noise_mean, '0', snr_select_noise, '0']
- [snr_noise_sum, '0', snr_noise_mean, '0']
- [snr_period_delay, '0', snr_difference, '1']
- [snr_power_floor, '0', model_snr_signal_floor, '1']
- [snr_power_floor, '0', snr_noise_floor, '1']
- [snr_power_floor, '0', snr_signal_floor, '1']
- [snr_ratio, '0', snr_db, '0']
- [snr_received_power, '0', snr_total_sum, '0']
- [snr_select_noise, '0', snr_noise_floor, '0']
- [snr_select_noise, '0', snr_signal_power, '1']
- [snr_select_total, '0', snr_signal_power, '0']
- [snr_signal_floor, '0', snr_ratio, '0']
- [snr_signal_power, '0', snr_signal_floor, '0']
- [snr_skip_noise, '0', snr_difference_power, '0']
- [snr_skip_signal, '0', snr_received_power, '0']
- [snr_total_mean, '0', snr_select_total, '0']
- [snr_total_sum, '0', snr_total_mean, '0']
- [sum_lags, '0', scale_correction, '0']
- [sum_periods, '0', select_windows, '0']
- [throttle, '0', tx_scale, '0']
- [tx_position_socket, pdus, rt_channel, tx_position]
- [tx_scale, '0', rt_channel, '0']
- [tx_scale_0_0, '0', tap_plot, '1']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
